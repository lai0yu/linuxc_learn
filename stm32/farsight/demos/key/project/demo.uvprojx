# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin .\Objects\demo.axf -o .\Objects\demo.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\app;..\driver\inc;..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/: main.c stm32f10x_it.c
  group cmsis
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group driver
    ../driver/src/: drv_led.c drv_led_rigister.c drv_sysclk.c drv_systick.c drv_keypress.c drv_usart1.c drv_usart1_it.c drv_keypress_exti.c drv_tim6_it.c drv_common_tim3.c drv_tim3_it_breath.c drv_dma.c
  group startup
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdlib
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c misc.c
